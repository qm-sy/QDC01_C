# Keil uVision project LED.uvproj, settings and files
target LED (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Screen_485 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP\Inc;.\Core\Inc;.\Emembed\Inc
  link misc: REMOVEUNUSED
  group Source
    ./: lcd.c touch.c isr.asm main.c
  group Core
    ./Core/Src/: gpio.c tim.c uart.c
  group BSP
    ./BSP/Src/: communication.c tm1722.c delay.c
  group Emembed
    ./Emembed/Src/: modbus_rtu.c
